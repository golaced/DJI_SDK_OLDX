# Keil uVision project Stm32PingExample.uvprojx, settings and files
target DJIOSDK_Ping (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Stm32PingExample +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__FPU_USED
  c misc: --gnu
  c include: ..\..\..\..\sample\STM32\OnBoardSDK_STM32\Lib\CMSIS\inc;..\..\..\..\sample\STM32\OnBoardSDK_STM32\Lib\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\lib\inc;..\..\PingLib;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.cpp DroneInterface.cpp bsp.cpp
  group Ping_LIB
    ../../PingLib/: Ping.cpp
  group DJIOSDK_LIB
    ../../../../lib/src/: DJI_API.cpp DJI_App.cpp DJI_Camera.cpp DJI_Codec.cpp DJI_Flight.cpp DJI_Follow.cpp DJI_HardDriver.cpp DJI_HotPoint.cpp DJI_Link.cpp DJI_Memory.cpp DJI_Mission.cpp DJI_VirtualRC.cpp DJI_WayPoint.cpp
  group STM32_LIB
    ../../../../sample/STM32/OnBoardSDK_STM32/Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../../../sample/STM32/OnBoardSDK_STM32/Lib/CMSIS/src/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.5.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
